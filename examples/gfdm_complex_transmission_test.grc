<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gfdm_complex_test</value></param>
<param><key>author</key><value>Andrej Rode</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>GFDM Full Test</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>active_subcarriers</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>block_len</value></param>
<param><key>value</key><value>timeslots * fft_len</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cp_len</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f_taps</value></param>
<param><key>value</key><value>filters.get_frequency_domain_filter('rrc', rolloff, timeslots, fft_len, overlap)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_gap</value></param>
<param><key>value</key><value>np.zeros(frame_len)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_len</value></param>
<param><key>value</key><value>window_len + len(preamble0)</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>gfdm_const</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ic_range</value></param>
<param><key>value</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>overlap</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble0</value></param>
<param><key>value</key><value>pre_module.mapped_preamble(seed, 'rrc', .5, active_subcarriers, fft_len, subcarrier_map, overlap, cp_len, ramp_len)[0]/fft_len</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble1</value></param>
<param><key>value</key><value>pre_module.mapped_preamble(seed, 'rrc', .5, active_subcarriers, fft_len, subcarrier_map, overlap, cp_len, ramp_len)[1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_f_taps</value></param>
<param><key>value</key><value>filters.get_frequency_domain_filter('rrc', rolloff, 2, fft_len, 2)/fft_len</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_vals</value></param>
<param><key>value</key><value>utils.get_random_qpsk(active_subcarriers, seed)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ramp_len</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rolloff</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_0</value></param>
<param><key>value</key><value>usrp_rate / 32.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>seed</value></param>
<param><key>value</key><value>abs(hash('awesome')) % (2**32)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>subcarrier_map</value></param>
<param><key>value</key><value>np.concatenate((np.arange(active_subcarriers // 2), np.arange(fft_len - active_subcarriers // 2, fft_len)))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>timeslots</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_rate</value></param>
<param><key>value</key><value>100e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>window_len</value></param>
<param><key>value</key><value>block_len + cp_len</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>window_taps</value></param>
<param><key>value</key><value>cyclic_prefix.get_root_raised_cosine_ramp(ramp_len, window_len)</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>len(gfdm_const.points())</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>10000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>0.0</value></param>
<param><key>noise_voltage</key><value>0.0</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>gfdm_const.points()</value></param>
</block>
<block>
<key>blocks_vector_insert_x</key>
<param><key>id</key><value>frame_gap_vector_insert</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>period</key><value>frame_len + len(frame_gap)</value></param>
<param><key>vector</key><value>frame_gap</value></param>
</block>
<block>
<key>hier_gfdm_transmitter</key>
<param><key>id</key><value>hier_gfdm_transmitter_0</value></param>
<param><key>active_subcarriers</key><value>active_subcarriers</value></param>
<param><key>cp_len</key><value>cp_len</value></param>
<param><key>filter_taps</key><value>f_taps</value></param>
<param><key>overlap</key><value>overlap</value></param>
<param><key>preamble</key><value>preamble0</value></param>
<param><key>ramp_len</key><value>ramp_len</value></param>
<param><key>subcarrier_map</key><value>subcarrier_map</value></param>
<param><key>subcarriers</key><value>fft_len</value></param>
<param><key>timeslots</key><value>timeslots</value></param>
<param><key>window_taps</key><value>window_taps</value></param>
</block>
<block>
<key>hier_receiver_chain</key>
<param><key>id</key><value>hier_receiver_chain_0</value></param>
<param><key>acorr_thr</key><value>0.9</value></param>
<param><key>active_subcarriers</key><value>active_subcarriers</value></param>
<param><key>constellation</key><value>gfdm_const</value></param>
<param><key>cp_len</key><value>cp_len</value></param>
<param><key>filter_taps</key><value>f_taps</value></param>
<param><key>ic</key><value>ic_range</value></param>
<param><key>overlap</key><value>overlap</value></param>
<param><key>preamble</key><value>preamble1</value></param>
<param><key>preamble_f_taps</key><value>preamble_f_taps</value></param>
<param><key>preamble_vals</key><value>preamble_vals</value></param>
<param><key>ramp_len</key><value>ramp_len</value></param>
<param><key>subcarrier_map</key><value>np.arange(active_subcarriers)</value></param>
<param><key>subcarriers</key><value>fft_len</value></param>
<param><key>timeslots</key><value>timeslots</value></param>
<param><key>window_taps</key><value>window_taps</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gfdm.pygfdm import utils</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_cyclic_prefix</value></param>
<param><key>import</key><value>from gfdm.pygfdm import cyclic_prefix</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_filters</value></param>
<param><key>import</key><value>from gfdm.pygfdm import filters</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_numpy</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_synchronization</value></param>
<param><key>import</key><value>from gfdm.pygfdm import preamble as pre_module</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>size</key><value>block_len</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>2*frame_len</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>timeslots*fft_len</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>tx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>tx</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>hier_receiver_chain_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>hier_gfdm_transmitter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>frame_gap_vector_insert</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_gfdm_transmitter_0</source_block_id><sink_block_id>frame_gap_vector_insert</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_receiver_chain_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_receiver_chain_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_receiver_chain_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
