<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>hier_receiver_chain</value></param>
<param><key>author</key><value>Andrej Rode</value></param>
<param><key>category</key><value>GFDM</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>GFDM Receiver Chain</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>block_len</value></param>
<param><key>value</key><value>timeslots * subcarriers</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>window_len</value></param>
<param><key>value</key><value>block_len + cp_len</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>acorr_thr</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>active_subcarriers</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>110</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>constellation</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cp_len</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>filter_taps</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>gfdm_advanced_receiver_sb_cc</key>
<param><key>id</key><value>gfdm_advanced_receiver_sb_cc_0</value></param>
<param><key>constellation</key><value>constellation</value></param>
<param><key>frequency_taps</key><value>filter_taps</value></param>
<param><key>ic_iter</key><value>ic</value></param>
<param><key>overlap</key><value>overlap</value></param>
<param><key>timeslots</key><value>timeslots</value></param>
<param><key>subcarriers</key><value>subcarriers</value></param>
</block>
<block>
<key>gfdm_channel_estimator_cc</key>
<param><key>id</key><value>gfdm_channel_estimator_cc_0</value></param>
<param><key>subcarriers</key><value>subcarriers</value></param>
<param><key>timeslots</key><value>timeslots</value></param>
<param><key>gfdm_block_tag_key</key><value>"gfdm_block"</value></param>
<param><key>preamble_data</key><value>preamble_vals</value></param>
<param><key>preamble_f_taps</key><value>preamble_f_taps</value></param>
<param><key>cp_len</key><value>cp_len</value></param>
</block>
<block>
<key>gfdm_sync_cc</key>
<param><key>id</key><value>gfdm_sync_cc_0</value></param>
<param><key>n_subcarriers</key><value>subcarriers</value></param>
<param><key>thr_acorr</key><value>acorr_thr</value></param>
<param><key>cp_length</key><value>cp_len</value></param>
<param><key>frame_len</key><value>subcarriers*timeslots+2*subcarriers+cp_len</value></param>
<param><key>gfdm_tag_key</key><value>"gfdm_block"</value></param>
<param><key>preamble</key><value>preamble</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ic</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_numpy</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>overlap</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>[0]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble_f_taps</value></param>
<param><key>value</key><value>[0]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble_vals</value></param>
<param><key>value</key><value>[0]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ramp_len</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>subcarrier_map</value></param>
<param><key>value</key><value>np.arange(110)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>subcarriers</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>timeslots</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>window_taps</value></param>
<param><key>value</key><value>[1,]</value></param>
</block>
<connection><source_block_id>gfdm_advanced_receiver_sb_cc_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_channel_estimator_cc_0</source_block_id><sink_block_id>gfdm_advanced_receiver_sb_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_sync_cc_0</source_block_id><sink_block_id>gfdm_channel_estimator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>gfdm_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
