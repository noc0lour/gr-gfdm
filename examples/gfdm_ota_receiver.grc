<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gfdm_ota_receiver</value></param>
<param><key>author</key><value>Andrej Rode</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>active_subcarriers</value></param>
<param><key>value</key><value>110</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>block_len</value></param>
<param><key>value</key><value>timeslots * subcarriers</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cp_len</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f_taps</value></param>
<param><key>value</key><value>filters.get_frequency_domain_filter('rrc', rolloff, timeslots, subcarriers, overlap)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_len</value></param>
<param><key>value</key><value>window_len + len(preamble)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>2.484e9</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>gfdm_const</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>overlap</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>pre_module.mapped_preamble(seed, 'rrc', .5, active_subcarriers, subcarriers, subcarrier_map, overlap, cp_len, ramp_len)[1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_vals</value></param>
<param><key>value</key><value>utils.get_random_qpsk(active_subcarriers, seed)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ramp_len</value></param>
<param><key>value</key><value>cp_len // 4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rolloff</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>usrp_rate / 64.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>seed</value></param>
<param><key>value</key><value>abs(hash('awesome')) % (2**32)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>subcarrier_map</value></param>
<param><key>value</key><value>np.concatenate((np.arange(active_subcarriers // 2), np.arange(subcarriers- active_subcarriers // 2, subcarriers)))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>subcarriers</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>timeslots</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_rate</value></param>
<param><key>value</key><value>100e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>window_len</value></param>
<param><key>value</key><value>block_len + cp_len</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>window_taps</value></param>
<param><key>value</key><value>cyclic_prefix.get_root_raised_cosine_ramp(ramp_len, window_len)</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.5</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>filter</key><value>"cfo"</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>gfdm_advanced_receiver_sb_cc</key>
<param><key>id</key><value>gfdm_advanced_receiver_sb_cc_0</value></param>
<param><key>constellation</key><value>gfdm_const</value></param>
<param><key>frequency_taps</key><value>f_taps</value></param>
<param><key>ic_iter</key><value>16</value></param>
<param><key>overlap</key><value>overlap</value></param>
<param><key>timeslots</key><value>timeslots</value></param>
<param><key>subcarriers</key><value>subcarriers</value></param>
</block>
<block>
<key>gfdm_channel_estimator_cc</key>
<param><key>id</key><value>gfdm_channel_estimator_cc_0</value></param>
<param><key>subcarriers</key><value>subcarriers</value></param>
<param><key>timeslots</key><value>timeslots</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>gfdm_block_tag_key</key><value>"gfdm_block"</value></param>
<param><key>preamble</key><value>preamble</value></param>
<param><key>cp_len</key><value>cp_len</value></param>
</block>
<block>
<key>gfdm_sync_cc</key>
<param><key>id</key><value>gfdm_sync_cc_0</value></param>
<param><key>n_subcarriers</key><value>subcarriers</value></param>
<param><key>thr_acorr</key><value>0.5</value></param>
<param><key>cp_length</key><value>cp_len</value></param>
<param><key>frame_len</key><value>subcarriers*timeslots+2*subcarriers+cp_len</value></param>
<param><key>gfdm_tag_key</key><value>"gfdm_block"</value></param>
<param><key>preamble</key><value>preamble</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gfdm.pygfdm import utils</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_cyclic_prefix</value></param>
<param><key>import</key><value>from gfdm.pygfdm import cyclic_prefix</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_filters_0</value></param>
<param><key>import</key><value>from gfdm.pygfdm import filters</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_numpy</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_synchronization</value></param>
<param><key>import</key><value>from gfdm.pygfdm import preamble as pre_module</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>0</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>gfdm_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_advanced_receiver_sb_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_channel_estimator_cc_0</source_block_id><sink_block_id>blocks_tag_debug_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_channel_estimator_cc_0</source_block_id><sink_block_id>gfdm_advanced_receiver_sb_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_sync_cc_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_sync_cc_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_sync_cc_0</source_block_id><sink_block_id>gfdm_channel_estimator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
